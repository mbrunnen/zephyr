## tests/drivers/led_strip/testcase.yaml
```yaml
tests:
  drivers.led_strip.ws2812_gpio:
    type: unit
    tags:
      - drivers
      - led_strip
```
